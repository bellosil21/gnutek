<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block2</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Spectrum Analyzer</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>2.4e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>3e6</value></param>
<param><key>min</key><value>1e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfa</value></param>
<param><key>value</key><value>91000000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>frequency</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>100.6e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>150e6</value></param>
<param><key>min</key><value>80e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>40</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.5e6</value></param>
</block>
<block>
<key>TekRSA_iq_stream</key>
<param><key>id</key><value>TekRSA_iq_stream_0</value></param>
<param><key>in_bw</key><value>2e6</value></param>
<param><key>in_ctrfreq</key><value>frequency</value></param>
<param><key>in_devid</key><value>0</value></param>
<param><key>in_reflvl</key><value>-20</value></param>
<param><key>in_recLen</key><value>1000000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>bandwidth</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>fft_size</key><value>521</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-40</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>bandwidth</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.hamming</value></param>
</block>
<connection><source_block_id>TekRSA_iq_stream_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
